## Config.in
```kconfig
config BR2_PACKAGE_VPBUS_TEST
	bool vpbus_test
	help
	  Application de test pour le driver vpbus
```
